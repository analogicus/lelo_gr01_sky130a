v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -30 -20 0 0 {name=p1 lab=clk}
C {devices/ipin.sym} -30 30 0 0 {name=p2 lab=rst}
C {devices/ipin.sym} -30 80 0 0 {name=p3 lab=request}
C {devices/ipin.sym} -30 140 0 0 {name=p4 lab=oscillator_clk}
C {devices/opin.sym} 130 -10 0 0 {name=p5 lab=pwr}
C {devices/opin.sym} 130 50 0 0 {name=p6 lab=done}
C {devices/opin.sym} 130 110 0 0 {name=p7 lab=out[7:0]}
C {devices/ipin.sym} -30 -60 0 0 {name=p8 lab=VGND}
C {devices/ipin.sym} -30 -100 0 0 {name=p9 lab=VPWR}
